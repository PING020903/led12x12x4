# Keil uVision project led12x24.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8C2K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: led12x24 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  group Source Group 1
    ./: STARTUP.A51
  group include
    ./include/: STC8C.h GPIO_init.h ShowStrings.h
  group source
    ./source/: main.c GPIO_init.c ShowStrings.c
